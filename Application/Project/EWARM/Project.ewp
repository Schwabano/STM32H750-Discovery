# IAR project Project.ewp, settings and files
configuration STM32H750-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750B-DK ST STM32H750B-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; STM32H750xx; USE_STM32H750B_DK; EW_USE_OPERATING_SYSTEM=1; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Include; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\BSP\STM32H750B-DK; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\BSP\Components\Common; ..\..\..\TargetSpecific\Drivers; ..\..\..\TargetSpecific; ..\..\Source; ..\..\GeneratedCode; ..\..\..\PlatformPackage\RTE; ..\..\GeneratedCode\EmWiGfxInclude; ..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\include; ..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-STM32H750-Discovery.hex
  ILINK.IlinkOutputFile: EmbeddedWizard-STM32H750-Discovery.out
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c main.c
    ./: startup_stm32h750xx.s
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c stm32h7xx_it.c system_stm32h7xx.c
  group Application/TargetSpecific/Drivers
    ../../../TargetSpecific/Drivers/: ft5336.c ft5336_reg.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32H750B_Discovery
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c stm32h750b_discovery_bus.c stm32h750b_discovery_ts.c
  group Drivers/STM32FHxx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_ll_fmc.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: _ApplicationFontLarge.h _ApplicationFontSmall.h _ApplicationLogo.h Application.c Core.c Effects.c Graphics.c Resources.c Views.c
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: ewextgfx.c libewgfx-m7-iar.a
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewextrte.c libewrte-m7-iar.a
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
