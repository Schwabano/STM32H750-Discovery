# IAR project Project.ewp, settings and files
configuration STM32H750B_DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750B-DISCO ST STM32H750B-DISCO
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H750xx
  ICCARM.CCIncludePath2: ..\..\Source; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Include; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\BSP\STM32H750B-DK; ..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\BSP\Components
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32H745I_DISCO.out
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../../Source/: fmc.c main.c memory_msp.c mmc.c qspi.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../../Source/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c
